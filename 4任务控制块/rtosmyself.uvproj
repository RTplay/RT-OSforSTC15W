# Keil uVision project rtosmyself.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: rtosmyself +hex
  c flags: SizeSpeed=1
  c define: STACK_DETECT_MODE
  c include: .\bsp;.\RT_OS
  group Source
    ./: main.c
  group bsp
    ./bsp/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c timer.c USART.C
  group RT_OS
    ./RT_OS/: rt_os_core.c
