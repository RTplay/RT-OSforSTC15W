# Keil uVision project rtosmyself.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: rtosmyself +hex
  c flags: SizeSpeed=1
  c define: SYSTEM_DETECT_MODE,DEBUG_ENABLE,xMUTEX_ENABLE,xSEM_ENABLE,xMSGQ_ENABLE,xFLAG_ENABLE,xMEM_ENABLE
  c include: .\bsp;.\RT_OS;.\driver;.\RTWing
  group Source
    ./: main.c
  group bsp
    ./bsp/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c timer.c USART.C
  group RT_OS
    ./RT_OS/: rt_os_core.c rt_os_task.c rt_os_asm.c rt_os_time.c rt_os_detect.c
  group driver
    ./driver/: debug_uart.c
  group RT_ITC
    ./RT_ITC/: rt_os_mutex.c rt_os_sem.c rt_os_msgq.c rt_os_flag.c
  group RT_MEM
    ./RT_MEM/: rt_os_mem.c
  group RTWing
    ./RTWing/: RTWing.c
